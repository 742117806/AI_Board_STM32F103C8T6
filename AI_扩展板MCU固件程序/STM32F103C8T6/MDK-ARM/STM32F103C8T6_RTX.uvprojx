# Keil uVision project STM32F103C8T6_RTX.uvprojx, settings and files
target STM32F103C8T6_RTX (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103C8T6_V0302_490M +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;    ../Drivers/CMSIS/Include;    ..\Drivers\BSP\Inc;    ..\RTX\SRC;    ..\xiao ai
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group RTX_Config
    ../RTX_Config/: RTX_Conf_CM.c
  group Application/User
    ../Src/: delay.c taskApp.c user_call_back.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
    ../Inc/: deviceInfo.h frameType.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group Drivers/BSP
    ../Drivers/BSP/Src/: spi.c uart.c wireless_app.c wireless_drv.c stmflash.c sn3218a_i2c.c stm32f0_eeprom.c stm32f0_usart.c
  group RTX/Source
    ../RTX/SRC/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group RTX/Port
    ../RTX/SRC/: HAL_CM3.c SVC_Table.s rt_HAL_CM.h
  group xiaoai
    ../xiao ai/: 74.c aes.c crc16.c frame_process.c led.c rout.c rsa.c touch.c
software components: CMSIS:CORE 4.3.0
